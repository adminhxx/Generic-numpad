## config/boards/shields/generic-numpad/Kconfig.defconfig
```kconfig
if SHIELD_GENERIC_NUMPAD

config ZMK_KEYBOARD_NAME
    default "generic-numpad"

endif
```
